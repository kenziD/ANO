# Keil uVision project Project.uvprojx, settings and files
target STM32_Project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\FWlib\inc;..\FWlib\src;..\User;..\Hardware;..\Hardware\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../CMSIS/Startup/: startup_stm32f10x_md.s
  group User
    ./: main.c stm32f10x_it.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_spi.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Hardware
    ../Hardware/: config.c delay.c HSEconf.c LED.c sys.c usart.c IIC.c IMU.C MPU6050.c MOTOR.c 24l01.c spi.c wave.c PID.c timer.c
